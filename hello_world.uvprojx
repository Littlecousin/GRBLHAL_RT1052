# Keil uVision project hello_world.uvprojx, settings and files
target hello_world debug (6160000::V6.16::ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, MCUXPRESSO_SDK
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: board;CMSIS;component/lists;component/uart;device;drivers;utilities;xip;.\Grbl;source;.\Grbl\inc
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052/arm/MIMXRT1052xxxxx_ram.scf
  link misc: --remove --entry=Reset_Handler
--remove
  group board
    board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group component/osa
    ./component/osa/: fsl_os_abstraction_config.h fsl_os_abstraction.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group component/phy
    ./component/phy/device/phyksz8081/: fsl_phyksz8081.c fsl_phyksz8081.h
    ./component/phy/mdio/enet/: fsl_enet_mdio.c fsl_enet_mdio.h
    ./component/phy/: fsl_mdio.h fsl_phy.h
    ./component/phy/device/phylan8720a/: fsl_phylan8720a.c fsl_phylan8720a.h
  group device
    device/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h
    ./drivers/: fsl_romapi.c fsl_romapi.h fsl_cache.h fsl_cache.c fsl_qtmr.c fsl_qtmr.h fsl_gpt.c fsl_gpt.h fsl_pit.c fsl_pit.h fsl_enet.c fsl_enet.h fsl_lpi2c.c fsl_lpi2c.h fsl_xbara.c fsl_xbara.h fsl_pwm.c fsl_pwm.h
  group source
    source/: main.c
    ./source/: main.h flexspi_romapi_ops.c bsp_nvic .c bsp_nvic.h bsp_tmr.c bsp_tmr.h bsp_gpt.c bsp_gpt.h bsp_pit.c bsp_pit.h bsp_key_it.c bsp_key_it.h bsp_rx_data_queue.c bsp_rx_data_queue.h bsp_uart.c bsp_uart.h ring_fifo.c ring_fifo.h bsp_usb_vom.c bsp_usb_vom.h bsp_flash.c bsp_flash.h eeprom_test.c bsp_i2c_eeprom.c bsp_i2c_eeprom.h core_delay.c core_delay.h bsp_led.c bsp_led.h RGBLED_DIALOG_BACKEND.c RGBLED_DIALOG_BACKEND.h
  group startup
    startup/: startup_MIMXRT1052.S
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
  group xip
    xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group grbl/core
    ./Grbl/grbl/: alarms.c coolant_control.c corexy.c errors.c gcode.c grbllib.c ioports.c limits.c maslow.c motion_control.c my_plugin.c ngc_expr.c ngc_params.c nuts_bolts.c nvs_buffer.c override.c pid.c planner.c protocol.c regex.c report.c settings.c sleep.c spindle_control.c state_machine.c stepper.c stream.c system.c tool_change.c wall_plotter.c alarms.h config.h coolant_control.h core_handlers.h corexy.h crossbar.h defaults.h driver_opts.h errors.h gcode.h grbl.h grbllib.h hal.h ioports.h kinematics.h limits.h maslow.h messages.h motion_control.h motor_pins.h ngc_expr.h ngc_params.h nuts_bolts.h nvs.h nvs_buffer.h override.h pid.h pin_bits_masks.h planner.h platform.h plugins.h plugins_init.h probe.h protocol.h README.md regex.h report.h settings.h sleep.h spindle_control.h spindle_sync.h state_machine.h stepdir_map.h stepper.h stream.h system.h tool_change.h wall_plotter.h
  group grbl/plugin/net
    ./Grbl/networking/: base64.c cJSON.c fs.c ftpd.c http_upload.c httpd.c multipartparser.c networking.c sfifo.c sha1.c strutils.c telnetd.c urldecode.c utils.c vfs.c websocketd.c
  group grbl/drivers
    ./Grbl/Src/: diskio.c driver.c flash.c i2c.c ioports.c serial.c usb_serial.c enet.c enet.h
    ./Grbl/Inc/: driver.h flash.h generic_map.h i2c.h my_machine.h serial.h spi.h usb_serial.h
  group grbl/plugin
    ./Grbl/eeprom/: eeprom_24AAxxx.c eeprom.h
  group usb/phy
    ./middleware/usb/phy/: usb_phy.c usb_phy.h
  group usb/device
    ./middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_class.c usb_device_class.h usb_device_ch9.c usb_device_ch9.h usb_device_dci.c usb_device_dci.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h
  group lwip
    ./middleware/lwip/port/: enet_ethernetif.c enet_ethernetif_kinetis.c sys_arch.c
    ./middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ./middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/app
    ./source/: lwip_tcpecho_test.c
    ./middleware/lwip/contrib/apps/tcpecho/: tcpecho.c tcpecho.h
  group FreeRTOS/src
    ./middleware/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./middleware/freertos/freertos_kernel/portable/MemMang/: heap_4.c
    ./middleware/freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c
  group FreeRTOS/inc
    ./middleware/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    ./middleware/freertos/freertos_kernel/portable/GCC/ARM_CM4F/: portmacro.h
    ./source/: FreeRTOSConfig.h
target hello_world flexspi_nor_debug (6160000::V6.16::ARMCLANG)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x018000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: hello_world.out
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1052CVL5B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, USB_STACK_FREERTOS, SDK_OS_FREE_RTOS, LWIP_DISABLE_PBUF_POOL_SIZE_SANITY_CHECKS=1, USE_RTOS=1,
  c misc: as above
  c include: board;CMSIS;component/lists;component/uart;component\osa;device;drivers;utilities;xip;.\Grbl;source;.\Grbl\inc;.\Grbl\networking;.\middleware\usb\device;.\middleware\usb\include;.\middleware\usb\phy;.\middleware\lwip\port;.\middleware\lwip\src\include;.\middleware\lwip\src\include\lwip;.\component\phy;.\component\phy;./component/phy/mdio/enet;./component/phy/device/phylan8720a;.\middleware\lwip\contrib\apps\tcpecho_raw;.\middleware\freertos\freertos_kernel\include;.\middleware\freertos\freertos_kernel\portable\GCC\ARM_CM4F;.\middleware\lwip\contrib\apps\tcpecho
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x18000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: MIMXRT1052/arm/MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
--remove
target hello_world sdram_debug (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, MCUXPRESSO_SDK
  c misc: as above
  c include: board;CMSIS;component/lists;component/uart;device;drivers;utilities;xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052/arm/MIMXRT1052xxxxx_sdram.scf
  link misc: --remove --entry=Reset_Handler
--remove
target hello_world flexspi_nor_sdram_debug (6160000::V6.16::ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, MCUXPRESSO_SDK, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  c misc: as above
  c include: board;CMSIS;component/lists;component/uart;component\osa;device;drivers;utilities;xip;.\Grbl;source;.\Grbl\inc;.\Grbl\networking;.\middleware\usb\device;.\middleware\usb\include;.\middleware\usb\phy;.\middleware\lwip\port;.\middleware\lwip\src\include;.\middleware\lwip\src\include\lwip;.\component\phy;.\component\phy;./component/phy/mdio/enet;./component/phy/device/phylan8720a;.\middleware\lwip\contrib\apps\tcpecho_raw
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052/arm/MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: as above
target hello_world sdram_txt_debug (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, MCUXPRESSO_SDK
  c misc: -ffunction-sections -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052/arm/MIMXRT1052xxxxx_sdram_txt.scf
  link misc: --remove --entry=Reset_Handler
--remove
target hello_world ram_0x1400_debug (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: evkbimxrt1050/demo_apps/hello_world/linker/MIMXRT1052xxxxx_ram_0x1400.scf
  link misc: --remove --entry=Reset_Handler
--remove
target hello_world release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052/arm/MIMXRT1052xxxxx_ram.scf
  link misc: --remove --entry=Reset_Handler
--remove
target hello_world flexspi_nor_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052/arm/MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: as above
target hello_world sdram_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052/arm/MIMXRT1052xxxxx_sdram.scf
  link misc: --remove --entry=Reset_Handler
--remove
target hello_world flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052/arm/MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: as above
target hello_world sdram_txt_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052/arm/MIMXRT1052xxxxx_sdram_txt.scf
  link misc: --remove --entry=Reset_Handler
--remove
target hello_world ram_0x1400_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: as above
  link misc: --remove --entry=Reset_Handler
--remove
